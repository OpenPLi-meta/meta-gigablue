SRCDATE = "20181121r1"

BOLT_DATE="2018-11-20"
BOLT_VERSION="1846"
BOLT_MD5SUM="d3e4560438dfda1548ca960c1d8812b8"
BOLT_DEVICE="/dev/mtdblock0"

require gigablue-bootloader.inc

SRC_URI[md5sum] = "92c678d485cee8d0185ac52cb5cc9efe"
SRC_URI[sha256sum] = "62f2c65d97984ee2b22230df344f466810dc941f1a0037fce9986ba6bf6a4ad1"
