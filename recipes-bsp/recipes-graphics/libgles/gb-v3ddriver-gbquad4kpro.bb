SRCDATE = "20241224.r0"

require gb-v3ddriver.inc
require gb-v3ddriver-gbquad4kpro.inc


PREFERRED_PROVIDER_virtual/egl = "gb-v3ddriver-gbquad4kpro"
PREFERRED_PROVIDER_virtual/libgles2 = "gb-v3ddriver-gbquad4kpro"

COMPATIBLE_MACHINE = "gbquad4kpro"
